Commit message: updated for ROStoPCL support

File: cartographer_ros/urdf/cart_2d.urdf (robot description, URDF)
Before this commit: robot cartographer_backpack_2d, 3 links, 2 joints
Joints:
- joint os1_link_joint: origin xyz=0.00 0. 0.0 rpy=0. 0 0 -> xyz=0.00 0. 0.03618 rpy=0. 0 0
